# Keil uVision project NewDevice.uvprojx, settings and files
target FLM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WE_STM32F103_W25Q128
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c FlashStk.s
  group bsp
    ./: stm32f103_flash_spi_port.c
