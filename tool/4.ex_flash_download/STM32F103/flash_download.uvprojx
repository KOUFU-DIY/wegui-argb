# Keil uVision project flash_download.uvprojx, settings and files
target flash_download (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: flash_download
  c flags: Optim=2 v6Lang=1 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x1000000
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\flash_download.sct
  link misc: --diag_suppress L6305
  group Flash_res
    ../../3.bin2c/output/embed/: merged_bin.c
