# Keil uVision project Project.uvprojx, settings and files
target WeGui_ARGB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --no-multibyte-chars
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Lcd_Port;..\..;..\..\Core;..\..\Core\widgets;..\..\STM32F103;..\MDK-ARM;..\..\Demo;..\..\Demo\preview;..\..\tool\1.font2c\output;..\..\tool\2.img2c\output\c;..\..\tool\3.bin2c\output
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group MDK-ARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_wwdg.c stm32f10x_usart.c
  group Lcd_Port
    ../../: we_user_config.h
    ../Lcd_Port/: stm32f103_hw_config.h stm32f103_lcd_dma_4spi_port.c stm32f103_lcd_hard_4spi_port.c stm32f103_lcd_soft_3spi_port.c stm32f103_lcd_soft_iic_port.c stm32f103_lcd_soft_4spi_port.c stm32f103_flash_hard_stdspi_port.c stm32f103_flash_dma_stdspi_port.c w25qxx.c gc9a01.c st7735.c ssd1306.c ssd1309.c ssd1312.c ssd1315.c ssd1327.c sh1106.c sh1107.c sh1108.c sh1115.c st7789v3.c st7789vw.c st7796s.c
  group User
    ../: main.c stm32f10x_it.c system_stm32f10x.c
  group we_core
    ../../Core/: image_res.h we_gui_driver.c dirty_driver.c we_font_text.c we_render.c
    ../../Core/components/: we_motion.c we_scroll.c
  group we_widget
    ../../Core/widgets/arc/: we_widget_arc.c
    ../../Core/widgets/btn/: we_widget_btn.c
    ../../Core/widgets/img/: we_widget_img.c
    ../../Core/widgets/img_ex/: we_widget_img_ex.c
    ../../Core/widgets/img_flash/: we_widget_img_flash.c
    ../../Core/widgets/font_flash/: we_widget_font_flash.c
    ../../Core/widgets/group/: we_widget_group.c
    ../../Core/widgets/label/: we_widget_label.c
    ../../Core/widgets/slideshow/: we_widget_slideshow.c
    ../../Core/widgets/checkbox/: we_widget_checkbox.c
    ../../Core/widgets/label_ex/: we_widget_label_ex.c
    ../../Core/widgets/chart/: we_widget_chart.c
    ../../Core/widgets/toggle/: we_widget_toggle.c
    ../../Core/widgets/progress/: we_widget_progress.c
    ../../Core/widgets/slider/: we_widget_slider.c
    ../../Core/widgets/scroll_panel/: we_widget_scroll_panel.c
    ../../Core/widgets/dropdown/: we_widget_dropdown.c
    ../../Core/widgets/stepper/: we_widget_stepper.c
    ../../Core/widgets/indicator/: we_widget_indicator.c
    ../../Core/widgets/line/: we_widget_line.c
    ../../Core/widgets/box/: we_widget_box.c
    ../../Core/widgets/gauge/: we_widget_gauge.c
    ../../Core/widgets/list/: we_widget_list.c
    ../../Core/widgets/roller/: we_widget_roller.c
    ../../Core/widgets/marquee/: we_widget_marquee.c
    ../../Core/widgets/toast/: we_widget_toast.c
    ../../Core/widgets/msgbox/: we_widget_msgbox.c
    ../../Core/widgets/imgbtn/: we_widget_imgbtn.c
    ../../Core/widgets/segdisp/: we_widget_segdisp.c
  group we_widget_preview
    ../../Core/widgets_preview/animimg/: we_widget_animimg.c
    ../../Core/widgets_preview/btnmatrix/: we_widget_btnmatrix.c
    ../../Core/widgets_preview/calendar/: we_widget_calendar.c
    ../../Core/widgets_preview/canvas/: we_widget_canvas.c
    ../../Core/widgets_preview/chart_bar/: we_widget_chart_bar.c
    ../../Core/widgets_preview/colorwheel/: we_widget_colorwheel.c
    ../../Core/widgets_preview/hold_btn/: we_widget_hold_btn.c
    ../../Core/widgets_preview/ime_pinyin/: we_pinyin_table.c we_pinyin.c we_widget_ime_pinyin.c
    ../../Core/widgets_preview/joystick/: we_widget_joystick.c
    ../../Core/widgets_preview/keyboard/: we_widget_keyboard.c
    ../../Core/widgets_preview/knob/: we_widget_knob.c
    ../../Core/widgets_preview/logview/: we_widget_logview.c
    ../../Core/widgets_preview/mask_group/: we_widget_mask_group.c
    ../../Core/widgets_preview/menu/: we_widget_menu.c
    ../../Core/widgets_preview/mlabel/: we_widget_mlabel.c
    ../../Core/widgets_preview/qrcode/: we_qr_encoder.c we_widget_qrcode.c
    ../../Core/widgets_preview/radio/: we_widget_radio.c
    ../../Core/widgets_preview/scale/: we_widget_scale.c
    ../../Core/widgets_preview/spectrum/: we_widget_spectrum.c
    ../../Core/widgets_preview/spinner/: we_widget_spinner.c
    ../../Core/widgets_preview/statusbar/: we_widget_statusbar.c
    ../../Core/widgets_preview/table/: we_widget_table.c
    ../../Core/widgets_preview/tabview/: we_widget_tabview.c
    ../../Core/widgets_preview/textarea/: we_widget_textarea.c
  group we_tool_bin
    ../../tool/2.img2c/output/c/: res_img.c
    ../../tool/1.font2c/output/: simli_16_2bpp.h simli_16_2bpp.c simsun_12_2bpp.c msyh_16_4bpp_ime.c gbsn00lp_2_16_4bpp.h gbsn00lp_2_16_4bpp.c
    ../../tool/3.bin2c/output/: merged_bin.h merged_bin.c
  group Demo
    ../../Demo/: demo_common.c demo_label.c demo_btn.c demo_img.c demo_img_alpha.c demo_img_ex.c demo_arc.c demo_concentric_arc.c demo_group.c demo_slideshow.c demo_checkbox.c demo_label_ex.c demo_chart.c demo_toggle.c demo_progress.c demo_msgbox.c demo_flash_img.c demo_flash_font.c demo_slider.c demo_scroll_panel.c demo_dropdown.c demo_stepper.c demo_indicator.c demo_line.c demo_box.c demo_gauge.c demo_list.c demo_roller.c demo_marquee.c demo_toast.c demo_focus.c demo_focus2.c demo_imgbtn.c demo_segdisp.c
  group demo_preview
    ../../Demo/preview/: demo_animimg.c demo_btnmatrix.c demo_calendar.c demo_canvas.c demo_chart_bar.c demo_colorwheel.c demo_hold_btn.c demo_ime_pinyin.c demo_joystick.c demo_keyboard.c demo_knob.c demo_logview.c demo_mask_group.c demo_menu.c demo_mlabel.c demo_qrcode.c demo_radio.c demo_scale.c demo_spectrum.c demo_spinner.c demo_statusbar.c demo_table.c demo_tabview.c demo_textarea.c
