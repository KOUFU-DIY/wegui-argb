# Keil uVision project Project.uvprojx, settings and files
target STM32F030 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F051K8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,WE_PLATFORM_STM32F030,USE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --no-multibyte-chars
  c include: ..\..;..\;..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Lcd_Port;..\..\Core;..\..\Core\widgets;..\..\Demo;..\..\tool\font2c\output;..\..\tool\bin2c\output
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group CMSIS
    ../: system_stm32f0xx.c
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s startup_stm32f0xx_ld.s startup_stm32f030xc.s startup_stm32f031.s startup_stm32f042.s startup_stm32f051.s startup_stm32f070x6.s startup_stm32f070xb.s startup_stm32f072.s startup_stm32f091.s
  group StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ../Lcd_Port/: stm32f030_hw_config.h stm32f030_lcd_hard_4spi_port.c stm32f030_lcd_soft_4spi_port.c stm32f030_lcd_dma_4spi_port.c gc9a01.c st7735.c st7789s.c st7789v3.c st7789vw.c st7796s.c
    ../../: we_user_config.h
    ../: main.c stm32f0xx_it.c
  group we_core
    ../../Core/: dirty_driver.c image_res.c we_font_text.c we_gui_driver.c we_motion.c
  group we_widget
    ../../Core/widgets/font_flash/: we_widget_font_flash.c
    ../../Core/widgets/group/: we_widget_group.c
    ../../Core/widgets/img/: we_widget_img.c
    ../../Core/widgets/img_ex/: we_widget_img_ex.c
    ../../Core/widgets/img_flash/: we_widget_img_flash.c
    ../../Core/widgets/label/: we_widget_label.c
    ../../Core/widgets/label_ex/: we_widget_label_ex.c
    ../../Core/widgets/msgbox/: we_widget_msgbox.c
    ../../Core/widgets/progress/: we_widget_progress.c
    ../../Core/widgets/scroll_panel/: we_widget_scroll_panel.c
    ../../Core/widgets/slider/: we_widget_slider.c
    ../../Core/widgets/slideshow/: we_widget_slideshow.c
    ../../Core/widgets/toggle/: we_widget_toggle.c
    ../../Core/widgets/arc/: we_widget_arc.c
    ../../Core/widgets/btn/: we_widget_btn.c
    ../../Core/widgets/chart/: we_widget_chart.c
    ../../Core/widgets/checkbox/: we_widget_checkbox.c
  group demo
    ../../Demo/: demo_arc.c demo_btn.c demo_chart.c demo_checkbox.c demo_common.c demo_concentric_arc.c demo_flash_font.c demo_flash_img.c demo_group.c demo_img.c demo_img_ex.c demo_label.c demo_label_ex.c demo_msgbox.c demo_progress.c demo_scroll_panel.c demo_slider.c demo_slideshow.c demo_toggle.c
  group we_tool_bin
    ../../tool/font2c/output/: arial_16_4bbp.h arial_16_4bbp.c msyh_24_2bbp_ascii_menu_mix.h msyh_24_2bbp_ascii_menu_mix.c msyh_16_4bbp_ascii_menu_mix.h msyh_16_4bbp_ascii_menu_mix.c
    ../../tool/bin2c/output/: merged_bin.h merged_bin.c
